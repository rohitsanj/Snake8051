# Keil uVision project SnakeGame.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: SnakeGame +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: misc.inc snake_game_2.asm
